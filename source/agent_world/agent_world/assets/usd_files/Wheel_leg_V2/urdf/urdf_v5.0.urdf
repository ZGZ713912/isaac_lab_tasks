Commit message: feat(wheel_leg_v2): enhance reward structure and diagnostics

File: source/agent_world/agent_world/assets/usd_files/Wheel_leg_V2/urdf/urdf_v5.0.urdf (robot description, URDF)
Before this commit: robot urdf_v5.0, 19 links, 18 joints
Links:
- link RR_link2: mass 0.84 -> 0.084
